# Keil uVision project CountIt.uvproj, settings and files
target T0-LED (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: CountIt +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\dev;..\src\main;..\obj
  group main
    ../src/main/: main.c
  group sys
    ../src/sys/: delay.c delay.h
  group dev
    ../src/dev/: led.c led.h setto.c setto.h t0.c t0.h
