# Keil uVision project clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\dev;..\src\main;..\src\sys
  group main
    ../src/main/: main.c
  group dev
    ../src/dev/: nixled.c nixled.h timer0init.c timer0init.h
  group sys
    ../src/sys/: delay.c delay.h
