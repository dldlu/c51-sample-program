# Keil uVision project WaterLED.uvproj, settings and files
target WaterLED (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: WaterLED +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\dev;..\src\main;..\src\sys
  group main
    ../src/main/: main.c
  group dev
    ../src/dev/: led.c led.h
  group sys
    ../src/sys/: delay.c delay.h
