# Keil uVision project obj.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: obj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\dev;..\src\main;..\src\sys
  group main
    ../src/main/: main.c
  group Water-Led
    ../src/dev/: led.c led.h
  group Switch
    ../src/dev/: switch.c switch.h
  group LCD1602
    ../src/dev/: 1602.c 1602.h
  group sys
    ../src/sys/: delay.c delay.h config.h
