# Keil uVision project obj.uvproj, settings and files
target NixLed (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: obj +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\dev;..\src\main;..\src\sys
  group main
    ../src/main/: main.c
  group sys
    ../src/sys/: config.h delay.c delay.h
  group dev
    ../src/dev/: nixled.c nixled.h
