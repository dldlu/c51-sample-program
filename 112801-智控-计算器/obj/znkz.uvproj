# Keil uVision project znkz.uvproj, settings and files
target znkz (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: znkz +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\hareword;..\user
  group user
    ../user/: main.c
  group hareword
    ../hareword/: delay.c delay.h 1602.c 1602.h key.c key.h nixled.c nixled.h
