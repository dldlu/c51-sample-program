# Keil uVision project Int0.uvproj, settings and files
target Int0-LED (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: Int0 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\src\dev;..\src\main;..\src\sys
  group main
    ../src/main/: main.c
  group dev
    ../src/dev/: int0.c int0.h led.c led.h setint0.c setint0.h
  group sys
    ../src/sys/: delay.c delay.h
